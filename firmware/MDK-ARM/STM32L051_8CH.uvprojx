# Keil uVision project STM32L051_8CH.uvprojx, settings and files
target STM32L051_8CH (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L051C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L051_8CH +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L051xx,USE_HAL_DRIVER
  c include: ../Core/Inc;                ../Drivers/STM32L0xx_HAL_Driver/Inc;                ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;                ../Drivers/CMSIS/Include;             ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/User/Core
    ../Core/Src/: main.c app_controller.c app_delay.c app_config.c ch8_measure.c hy65_protocol.c hy65_ascii_cmd.c zdyh_cmd.c wireless_board.c gpio.c usart.c stm32l0xx_it.c stm32l0xx_hal_msp.c mbslave.c
  group Drivers/CMSIS
    ./: startup_stm32l051xx.s
    ../Core/Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
software components: CMSIS:CORE 4.3.0
